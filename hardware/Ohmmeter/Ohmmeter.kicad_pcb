# Repository th-in-gs/LCDResistorMeasurer

File README.md:

# 'Instant' Resistor Measurer

This is a device that quickly measures the value of a resistor. Call it an ohmmeter if you insist.

I've written it up in more detail on my blog: https://www.blog.montgomerie.net/posts/2023-08-30-instant-resistor-measurer/

## KiCad design hardware/Ohmmeter/Ohmmeter.kicad_pcb

Parts:
C1, C2, C3, C4: 0.1uF; R_Axial_DIN0309_L9.0mm_D3.2mm_P2.54mm_Vertical
C5, C6, C12: 0.1uf; R_Axial_DIN0309_L9.0mm_D3.2mm_P2.54mm_Vertical
C7: 0.47uf; C_Rect_L7.0mm_W4.5mm_P5.00mm
C8, C11: 10uf; CP_Radial_D6.3mm_P2.50mm
C10: 0.01uf; C_Rect_L7.0mm_W2.0mm_P5.00mm
D1, D2, D3, D4, D5, D6: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
D7: LED; LED_D10.0mm
DS1: DGL-0401YG-4EH; PinHeader_1x20_P2.54mm_Horizontal
J1: Power; PinHeader_1x02_P2.54mm_Horizontal
JP1: Test Terminal; PinHeader_1x02_P2.54mm_Horizontal
Q1, Q2, Q3, Q4, Q5: KT361; KT-13
Q6, Q7: 2N4401; TO-92_Inline_Wide
Q8: MPSA56-AP; TO-92_Inline_Wide
R1, R2, R3, R4, R5, R6, R7, R8: 22K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R9: 47; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R10: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R11: 200; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R12: 2.11k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R13: 20K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R14: 200k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R15, R16: 1M; R_Axial_DIN0614_L14.3mm_D5.7mm_P5.08mm_Vertical
R17, R18, R19, R20, R21: 680; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R22, R23, R24, R25, R26: 22k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R27, R28: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1, U2, U4: LM741; DIP-8_W7.62mm_Socket
U3: L78L05_TO92; TO-92_Inline_Wide
U5: ATmega8A-PU; DIP-28_W7.62mm

Connections:
+3.3V: C1.2, C2.1, C11.1, C12.1, Q7.1 (E), R1.1, R2.1, R3.1, R4.1, R10.1, U1.2 (-), U5.7 (VCC), U5.20 (AVCC)
+5V: C5.1, DS1.19 (LEDA), U3.1 (VO)
+VDC: C6.1, C7.1, C8.1, J1.2, Q6.3 (C), Q7.3 (C), R22.1, R23.1, R24.1, R25.1, R26.1, R27.1, U1.7 (V+), U2.7 (V+), U3.3 (VI), U4.7 (V+)
-VDC: C5.2, C6.2, C7.2, C8.2, J1.1, Q8.3 (C), R9.1, R28.2, U1.4 (V-), U2.4 (V-), U3.2 (GND), U4.4 (V-)
ADC: C10.1, JP1.2 (B), R11.2, R12.2, R13.2, R14.2, R16.2, U5.28 (PC5)
AREF: C4.2, D1.2 (A), U5.21 (AREF)
GND: C1.1, C2.2, C3.2, C4.1, C10.2, C11.2, C12.2, JP1.1 (A), Q8.1 (E), R5.2, R6.2, R7.2, R8.2, U2.2 (-), U5.8 (GND), U5.22 (AGND)
unnamed: D1.1 (K), U4.3 (+)
unnamed: D2.2 (A), Q1.1 (E), R11.1
unnamed: D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), U4.2 (-)
unnamed: D3.2 (A), Q2.1 (E), R12.1
unnamed: D4.2 (A), Q3.1 (E), R13.1
unnamed: D5.2 (A), Q4.1 (E), R14.1
unnamed: D6.2 (A), Q5.1 (E), R15.1
unnamed: D7.2 (A), R27.2, U1.3 (+)
unnamed: D7.1 (K), R28.1, U2.3 (+)
unnamed: DS1.1 (COM1), R1.2, R5.1, U5.2 (PD0)
unnamed: DS1.2 (COM2), R2.2, R6.1, U5.3 (PD1)
unnamed: DS1.15 (COM3), R3.2, R7.1, U5.4 (PD2)
unnamed: DS1.16 (COM4), R4.2, R8.1, U5.5 (PD3)
unnamed: DS1.20 (LEDK), R9.2
unnamed: DS1.8 (SEB6), U5.13 (PD7)
unnamed: DS1.3 (SEG1), U5.6 (PD4)
unnamed: DS1.4 (SEG2), U5.9 (PB6/XTAL1)
unnamed: DS1.5 (SEG3), U5.10 (PB7/XTAL2)
unnamed: DS1.6 (SEG4), U5.11 (PD5)
unnamed: DS1.7 (SEG5), U5.12 (PD6)
unnamed: DS1.9 (SEG7), U5.14 (PB0)
unnamed: DS1.10 (SEG8), U5.15 (PB1)
unnamed: DS1.11 (SEG9), U5.16 (PB2)
unnamed: DS1.12 (SEG10), U5.17 (PB3)
unnamed: DS1.13 (SEG11), U5.18 (PB4)
unnamed: DS1.14 (SEG12), U5.19 (PB5)
unnamed: Q1.3 (B), R17.1, R22.2
unnamed: Q1.2 (C), Q2.2 (C), Q3.2 (C), Q4.2 (C), Q5.2 (C), Q6.1 (E)
unnamed: Q2.3 (B), R18.1, R23.2
unnamed: Q3.3 (B), R19.1, R24.2
unnamed: Q4.3 (B), R20.1, R25.2
unnamed: Q5.3 (B), R21.1, R26.2
unnamed: Q6.2 (B), U4.6
unnamed: Q7.2 (B), U1.6
unnamed: Q8.2 (B), U2.6
unnamed: R15.2, R16.1
unnamed: R17.2, U5.23 (PC0)
unnamed: R18.2, U5.24 (PC1)
unnamed: R19.2, U5.25 (PC2)
unnamed: R20.2, U5.26 (PC3)
unnamed: R21.2, U5.27 (PC4)
unnamed: C3.1, R10.2, U5.1 (PC6/~RESET)

Notes on the sheet:
Floating 3V voltage reference
The PNP transistors below have their emitter and collectors connected in the 'opposite' order to how they should be, and should be flipped if this design is updated. This will require rework of the board, since the physical transistors are in ECB order so can't just be flipped. This revision works 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

Board: 2 copper layers, 147.3 x 101.6 mm, 62 parts (0 on the bottom side), 49 nets.

## Commit log

2016-04-29 Initial empty commit.
2016-04-29 .gitignore
2016-04-29 Initial implementation, and platformio files.
2016-05-02 Working LCD display of things!
2019-08-16 Working test code.
2019-08-24 Run on internal 8MHz oscilator.
2019-08-24 Switch to standard types.
2019-08-24 Change to original LCD algorithm.
2019-08-25 LCD routines done(?) = counting up.
2019-08-26 Refactor LCD routines into a seperate class.
2019-09-01 Now displays ADC values from challen 5 on the LCD.
2019-12-08 Better fuse settings for startup.
2019-12-27 Documents.
2019-12-27 Progress.
2019-12-29 First working ohmmeter!
2019-12-30 First stab at full version.
2019-12-31 Fix symbol toggling.
2019-12-31 Add missing value.
2020-01-03 Somewhat working version. Switching with PNP transistors.
2020-01-03 More sensitive ranges. Untested.
2020-01-04 Working version.
2020-01-04 Indent.
2020-01-04 Updated .gitignore.
2020-01-04 First KiCad schematics (incomplete).
2020-01-04 Updates to schematic. Switch to using internal pull-ups.
2020-01-25 Hardware updates. Changed the algorithm to use fewer lookup tables.
2020-01-26 New ability to switch E value ranges.
2020-06-08 Correct fuse definitions.
2020-06-08 Proper volatiliy for LCD state.
2020-06-08 Various improvements.
2020-06-08 PCB Fixes.
2020-07-26 Optimizations. The qsort routines were ocaisionally using so much RAM they were causing the stack to collide with the static variables, and overriding the LCD storage, causing display artefacts!
2020-07-26 Make the display not so 'noisy'.
2023-03-20 Add case STLs.
2023-03-20 Update for KiCad 7.
2023-04-17 Switch PNP transistors around where possible - I used them all upside-down!
2023-04-17 Allow building for ATMega88p
2023-08-30 Better comments.
2023-08-30 Create LICENSE
    Add MIT license from GitHub template.
